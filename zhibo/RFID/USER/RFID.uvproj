# Keil uVision project RFID.uvproj, settings and files
target RFID (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: RFID +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\RFID;..\HARDWARE\KEY;..\HARDWARE\LCD;..\SYSTEM\usart;..\HARDWARE\BEEP;..\HARDWARE\LED;..\HARDWARE\PWM;..\HARDWARE\oled;..\HARDWARE\USART3;..\HARDWARE\my;..\HARDWARE\IIC;..\HARDWARE\ESP8266;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/RFID/: rc522.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/my/: myalg.c
    ../HARDWARE/ESP8266/: apsta.c common.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/oled/: OLED_I2C.c
    ../HARDWARE/IIC/: myiic.c
